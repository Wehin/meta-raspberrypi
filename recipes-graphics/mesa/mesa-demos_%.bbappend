# Both Raspis do not support gles1

PACKAGECONFIG_remove_rpi = "gles1"
